# Keil uVision project 光控数字温度时钟.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 光控数字温度时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: MAIN.C DS1302.C TLC1543.c
