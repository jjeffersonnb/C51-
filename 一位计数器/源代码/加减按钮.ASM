		ORG 0000H
MAIN:	MOV R0,#00H
		MOV P1,#3FH
LOOP:	JB P2.1,NEXT
		LCALL DELAY10ms
		JB P2.1,NEXT
		JNB P2.1,$
		INC R0
		CJNE R0,#10,DISPLAY
		MOV R0,#0
		SJMP DISPLAY
NEXT:	JB P2.0,LOOP
		LCALL DELAY10ms
		JB P2.0,LOOP
		JNB P2.0,$
		DEC R0
		CJNE R0,#0FFH,DISPLAY
		MOV R0,#9
DISPLAY:MOV DPTR,#CC_TAB
		MOV A,R0
		MOVC A,@A+DPTR
		MOV P1,A
		SJMP LOOP
DELAY10ms:
		MOV R6,#20
LOP:	MOV R7,#250
		DJNZ R7,$
		DJNZ R6,LOP
		RET
CC_TAB: DB 3FH,06H,5BH,4FH,66H,6DH,7DH,07H,7FH,6FH
		END