//串行方式0控制16只流水灯
#include <reg52.h>
#define uint unsigned int
#define uchar unsigned char

uchar code table[]={ 
0x01,0x03,0x07,0x0F,0x1F,0x3F,0x7F,0xFF,0xFE,
0xFC,0xF8,0xF0,0xE0,0xC0,0x80,0x00,0xFF,0x00,
0xFE,0xFD,0xFB,0xF7,0xEF,0xDF,0xBF,0x7F,0xBF,
0xDF,0xEF,0xF7,0xFB,0xFD,0xFE,0x00,0xFF,0x00};  //共36种状态

void Delay(uint x)
{
 	uchar i;
	while(x--)
	{
	 	for(i=0;i<120;i++);
	}
}

void main()
{
 	uchar i;
	SCON = 0x00;
	while(1)
	{ 	
		for(i=0;i<36;i++)
		{
			SBUF = table[i]; while(TI==0); TI=0;
			SBUF = table[++i]; while(TI==0); TI=0; 
			Delay(400);
		}
	 }
}