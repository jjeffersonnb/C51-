# Keil uVision project 串行数据转并行数据.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 串行数据转并行数据 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: 串行数据转并行数据.c
