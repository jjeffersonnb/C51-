			   ORG 0000H
MAIN:	MOV 30H,#04H
		MOV 31H,#05H
		MOV 32H,#06H
		MOV 33H,#07H
		MOV 34H,#08H
		MOV 35H,#09H
		MOV 36H,#00H
		MOV 37H,#01H
		MOV 38H,#02H
		MOV 39H,#03H
LOOP:	ACALL DISP
		SJMP LOOP

			ORG 0100H
DISP:	PUSH ACC
		PUSH DPH
		PUSH DPL
		MOV R2,#0AH
		MOV R0,#30H
DL0:	MOV A,@R0
		MOV DPTR,#TAB
		MOVC A,@A+DPTR
		MOV SBUF,A
DL1:	JNB TI,DL1
		CLR TI
		ACALL DELAY
		INC R0
		DJNZ R2,DL0
		POP DPL
		POP DPH
		POP ACC
		RET

			ORG 0200H
DELAY:	MOV R6,#250
LOP:	MOV R7,#250
		MOV R5,#250
		MOV R4,#250
		NOP
		NOP
		NOP
		NOP
		DJNZ R4,$
		DJNZ R5,$
		DJNZ R7,$
		DJNZ R6,LOP
		RET

			ORG 0300H
TAB:	DB 0C0H,0F9H,0A4H,0B0H,99H
		DB 92H,82H,0F8H,80H,90H
		DB 88H,83H,0C6H,0A1H,86H,83H

		END
