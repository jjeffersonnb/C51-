# Keil uVision project 数字温度计.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 数字温度计 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: LCD1602.C MAIN.C DS18B20.C
